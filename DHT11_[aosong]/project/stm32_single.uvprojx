# Keil uVision project stm32_single.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_single +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\STDLIB\inc;..\STDLIB\src;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: ili9320.c main.c stm32f10x_it.c AM23XX.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STDLIB
    ../STDLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group startcode
    ../CMSIS/startup/: startup_stm32f10x_md.s
