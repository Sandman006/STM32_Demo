# Keil uVision project MPU6050.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_FWLib\inc;..\User\HARDWARE\LED;..\User\HARDWARE\MPU6050;..\User\HARDWARE\MPU6050\DMP;..\User\HARDWARE\MPU6050\IIC;..\User\HARDWARE\OLED;..\User\HARDWARE\TIME23;..\User\SYSTEM\delay;..\User\SYSTEM\sys;..\User\SYSTEM\usart;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group User
    ../User/: main.c
  group Core
    ../User/: stm32f10x_it.c
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group Hardware
    ../User/HARDWARE/LED/: led.c
    ../User/HARDWARE/MPU6050/: MPU6050.c
    ../User/HARDWARE/MPU6050/IIC/: IIC.c
    ../User/HARDWARE/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/HARDWARE/OLED/: oled.c
    ../User/HARDWARE/TIME23/: TIME.c
  group System
    ../User/SYSTEM/delay/: delay.c
    ../User/SYSTEM/sys/: sys.c
    ../User/SYSTEM/usart/: usart.c
  group Readme
    ../: README.TXT
