# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app\inc;..\bsp\driver\inc;..\bsp\STM32F10x_StdPeriph_Driver\inc;..\bsp\core;..\ucos_iii\uc_cpu;..\ucos_iii\uc_cpu\ARM-Cortex-M3;..\ucos_iii\uc_lib;..\ucos_iii\ucos_iii\Source;..\ucos_iii\ucos_iii\Ports;..\ucos_iii\ucos_bsp;..\ucos_iii\ucos_config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/src/: main.c task_cfg.c
  group bsp
    ../bsp/driver/src/: bsp_init.c bsp_io.c bsp_delay.c
  group core
    ../bsp/core/: system_stm32f10x.c stm32f10x_it.c core_cm3.c
  group startup
    ../bsp/core/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../bsp/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ucosiii_bsp
    ../ucos_iii/ucos_bsp/: bsp.c
  group ucosiii_cpu
    ../ucos_iii/uc_cpu/ARM-Cortex-M3/: cpu_c.c cpu_a.asm
    ../ucos_iii/uc_cpu/: cpu_core.c
  group ucosiii_lib
    ../ucos_iii/uc_lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../ucos_iii/uc_lib/Ports/ARM-Cortex-M3/: lib_mem_a.asm
  group ucosiii_core
    ../ucos_iii/ucos_iii/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucosiii_port
    ../ucos_iii/ucos_iii/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group ucosiii_config
    ../ucos_iii/ucos_config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
