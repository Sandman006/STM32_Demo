# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sg90 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\fwlib\inc;..\user;..\hardware\TIMER;..\delay;..\hardware\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c
  group core
    ../core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group hardware
    ../hardware/TIMER/: pwm.c
    ../hardware/delay/: delay.c
  group fwlib
    ../fwlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
